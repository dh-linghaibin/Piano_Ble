# Keil uVision project PianoBle.uvprojx, settings and files
target PianoBle (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PianoBle
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER, USE_USB_OTG_FS
  c include: ..\user\inc;..\bsp\Libraries\CMSIS\Include;..\bsp\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\bsp\Libraries\STM32F10x_StdPeriph_Driver\inc;..\bsp\Libraries\STM32_USB_HOST_Library\Core\inc;..\bsp\Libraries\STM32_USB_HOST_Library\Class\HID\inc;..\bsp\Libraries\STM32_USB_HOST_Library\Core\inc;..\bsp\Libraries\STM32_USB_OTG_Driver\inc;..\user\STM32Arduino_bsp
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group bsp
    ../bsp/Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_cl.s
    ../bsp/Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
  group user
    ../user/src/: main.c stm32f10x_it.c usbh_hid_usr.c
  group lib
    ../bsp/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_rcc.c
  group usb
    ../bsp/Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
